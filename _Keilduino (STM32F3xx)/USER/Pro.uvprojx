# Keil uVision project Pro.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F302C8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Pro
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\RTE;..\USER;..\ArduinoAPI;..\Core;..\Core\STM32F30x_StdPeriph_Driver\inc;..\Core\CMSIS\Device\ST\STM32F30x\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c Print.cpp itoa.c HardwareSerial.cpp Stream.cpp WString.cpp WMath.cpp WireBase.cpp Wire.cpp Tone.cpp SPI.cpp
  group Core
    ../CORE/: delay.c
    ../Core/: gpio.c pwm.c timer.c exti.c
  group USER
    ./: main.cpp
  group StdPeriph_Driver
    ../Core/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_fmc.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group Startup
    ../Core/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s
  group CMSIS
    ../Core/: system_stm32f30x.c
software components: CMSIS:CORE 5.1.1
