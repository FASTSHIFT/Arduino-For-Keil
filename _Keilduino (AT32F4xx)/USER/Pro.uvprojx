# Keil uVision project Pro.uvprojx, settings and files
target AT32F4xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F403ZE ArteryTek
  pack: Keil.AT32F4xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Pro
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LIBRARY_VERSION,AT32F403Zx_HD,ARDUINO=111
  c include: ..\ArduinoAPI;..\Core;..\USER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ./: main.cpp
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c itoa.c HardwareSerial.cpp Print.cpp Stream.cpp SPI.cpp Tone.cpp Wire.cpp WireBase.cpp WMath.cpp WString.cpp
    ../ArduinoAPI/avr/: dtostrf.c
  group Core
    ../Core/: adc.c delay.c exti.c gpio.c timer.c pwm.c
  group Startup
    ./RTE/Device/AT32F403ZE/: startup_at32f403zx_hd.s
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.1, Device:StdPeriph Drivers:ADC 1.0.1, Device:StdPeriph Drivers:DMA 1.0.1, Device:StdPeriph Drivers:EXTI 1.0.1, Device:StdPeriph Drivers:Framework 1.0.1, Device:StdPeriph Drivers:GPIO 1.0.1, Device:StdPeriph Drivers:RCC 1.0.1, Device:StdPeriph Drivers:SPI 1.0.1, Device:StdPeriph Drivers:TIMER 1.0.1, Device:StdPeriph Drivers:USART 1.0.1, Device:System_AT32Fxx 1.0.1
