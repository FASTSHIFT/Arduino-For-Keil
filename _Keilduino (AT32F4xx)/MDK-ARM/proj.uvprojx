# Keil uVision project proj.uvprojx, settings and files
target AT32F4xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F413CB ArteryTek
  pack: Keil.AT32F4xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: proj
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: LIBRARY_VERSION,AT32F403Zx_HD,ARDUINO=111
  c misc: --gnu
  c include: ..\ArduinoAPI;..\Core;..\Libraries;..\USER
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ../USER/: main.cpp
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c HardwareSerial.cpp Print.cpp Stream.cpp SPI.cpp Tone.cpp Wire.cpp WireBase.cpp WMath.cpp WString.cpp
  group Core
    ../Core/: adc.c delay.c exti.c gpio.c timer.c pwm.c
  group Startup
    ../Core/startup/: startup_at32f403cx_hd.s startup_at32f403cx_xl.s startup_at32f403rx_hd.s startup_at32f403rx_xl.s startup_at32f403vx_hd.s startup_at32f403vx_xl.s startup_at32f403zx_hd.s startup_at32f403zx_xl.s startup_at32f413cx_hd.s startup_at32f413cx_md.s startup_at32f413kx_hd.s startup_at32f413kx_md.s startup_at32f413rx_hd.s startup_at32f413rx_md.s startup_at32f415c8t7.s startup_at32f415cbt7.s startup_at32f415cct7.s startup_at32f415k8u7-4.s startup_at32f415kbu7-4.s startup_at32f415kcu7-4.s startup_at32f415r8t7.s startup_at32f415r8t7-7.s startup_at32f415rbt7.s startup_at32f415rbt7-7.s startup_at32f415rct7.s startup_at32f415rct7-7.s
  group README
    ../: README.md
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.1, Device:StdPeriph Drivers:ADC 1.0.1, Device:StdPeriph Drivers:DMA 1.0.1, Device:StdPeriph Drivers:EXTI 1.0.1, Device:StdPeriph Drivers:Framework 1.0.1, Device:StdPeriph Drivers:GPIO 1.0.1, Device:StdPeriph Drivers:RCC 1.0.1, Device:StdPeriph Drivers:SPI 1.0.1, Device:StdPeriph Drivers:TIMER 1.0.1, Device:StdPeriph Drivers:USART 1.0.1, Device:System_AT32Fxx 1.0.1
