# Keil uVision project proj.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103TB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: proj
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARDUINO=111
  c misc: --gnu
  c include: ..\Core;..\Config;..\..\..\ArduinoAPI;..\..\..\Application;..\..\..\Libraries
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../../../Application/: main.cpp rt_sys.cpp
  group Config
    ../Config/: mcu_config.h
  group ArduinoAPI
    ../../../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp Stream.cpp Tone.cpp Wire.cpp WireBase.cpp WMath.cpp WString.cpp
  group Core
    ../Core/: mcu_type.h mcu_core.c mcu_core.h adc.c exti.c gpio.c pwm.c timer.c HardwareSerial.cpp SPI.cpp
    ../CORE/: delay.c
  group README
    ../: README.md
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
