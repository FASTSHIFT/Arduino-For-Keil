# Keil uVision project proj.uvprojx, settings and files
target AT32F4xx (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F435CGU7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.0.1
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: proj
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: ARDUINO=111
  c misc: --gnu --diag_warning=4017
  c include: ..\ArduinoAPI;..\Core;..\Libraries;..\USER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group USER
    ../USER/: mcu_config.h main.cpp
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp Stream.cpp Wire.cpp WireBase.cpp WMath.cpp WString.cpp
  group Core
    ../Core/: mcu_type.h mcu_config_template.h at32f435_437_clock.c adc.c delay.c exti.c gpio.c timer.c pwm.c HardwareSerial.cpp SPI.cpp Tone.cpp
  group README
    ../: README.md
software components: CMSIS:CORE 5.3.0, Device:at32f435_437_conf 2.0.0, Device:at32f435_437_firmware_library:adc 2.0.0, Device:at32f435_437_firmware_library:crm 2.0.0, Device:at32f435_437_firmware_library:dma 2.0.0, Device:at32f435_437_firmware_library:exint 2.0.0, Device:at32f435_437_firmware_library:gpio 2.0.0, Device:at32f435_437_firmware_library:misc 2.0.0, Device:at32f435_437_firmware_library:scfg 2.0.0, Device:at32f435_437_firmware_library:spi 2.0.0, Device:at32f435_437_firmware_library:tmr 2.0.0, Device:at32f435_437_firmware_library:usart 2.0.0, Device:startup 2.0.0
