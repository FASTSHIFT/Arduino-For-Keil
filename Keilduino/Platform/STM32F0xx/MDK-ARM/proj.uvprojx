# Keil uVision project proj.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: proj
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARDUINO=111
  c misc: --gnu
  c include: ..\Config;..\Core;..\Core\STM32F0xx_StdPeriph_Driver\inc;..\Core\CMSIS\Device\ST\STM32F0xx\Include;..\Core\CMSIS\Include;..\..\..\Application;..\..\..\ArduinoAPI;..\..\..\Libraries
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Application
    ../../../Application/: main.cpp rt_sys.cpp
  group Config
    ../Config/: mcu_config.h
  group ArduinoAPI
    ../../../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp Stream.cpp Tone.cpp Wire.cpp WireBase.cpp WMath.cpp WString.cpp
  group Core
    ../Core/: mcu_type.h mcu_core.h mcu_core.c adc.c exti.c gpio.c pwm.c timer.c HardwareSerial.cpp SPI.cpp
    ../CORE/: delay.c
  group StdPeriph_Driver
    ../Core/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group Startup
    ../Core/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group CMSIS
    ../Core/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group README
    ../: README.md
software components: CMSIS:CORE 5.3.0
